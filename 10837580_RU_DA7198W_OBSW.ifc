Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-07T06:48:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 07 06:48:18 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{2E0DA655-C69B-4690-8957-ACF6E0CA91F2}\ifc * Database version: 5507 * Database creation date: Wed Jul 07 06:48:17 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 07 06:48:18 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 07 06:48:18 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28719840_RU_10837580_DA7198W_OBSW, 10837580_RU_DA7198W_OBSW:28719840_RU_10837580_DA7198W_OBSW:209452
In: Level 1
Type - Material: z_Miele_Design_OBSW, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, Aluminum, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - Reference: 28719840_RU_10837580_DA7198W_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
